# Keil uVision project GPIO_lab.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GPIO_lab +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group MCAL_INC
    ./: GPIO.h GPIO_CONFIG.h RCC.h RCC_CONFIG.h STD_TYPES.h
  group MCAL_SRC
    ./: GPIO.c RCC.c
  group Aplication
    ./: main.c
software components: CMSIS:CORE 5.5.0, Device:Startup 2.6.3
